<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SYSTEM_MENHOLL_103C8T.ewp</path>
  </project>
  <batchBuild />
</workspace>
